# Repository guidoschreuder/zebus

File README.org:

#+TITLE:     Zebus
#+AUTHOR:    Guido Schreuder
#+EMAIL:     guido.schreuder@ruimtepuin.be

* Manage the Valliant heater

** Goals
Create system to control the heater

Conceived features:
- room controller:
  - display to represent status
    - requested room temperature
    - room temperature
    - heater flow temp (ebusd message 'FlowTemp', also rounded in `status01`)
    - heater return temp (ebusd message 'ReturnTemp', also rounded in `status01`)
    - outside temperature
    - heater mode: heating/hot water (ebusd message 'HwcDemand' or 'HwcWaterflow')
    - tap water temperature (ebusd message 'FlowTemp' when tap is running)
    - flame on/off (ebusd message 'Flame')
    - pump on/off (ebusd message 'WP')
    - heater modulation
    - power usage (?) to be tested (ebusd message 'PowerValue')
  - sensor for actual room temperature
  - controls to set required temperature
- +communicate date and outside temperature to heater unit+ impossible and irrelevant, see [[* +Broadcast datetime+]]
- control remotely using a telegram bot, that way we do not need to open any ports to the outside
- (LOW PRIO, MAYBE LATER) display graphs over time of relevant values

** Topology (work in progress)
- room controller (ESP32 + display + temp-sensor)
- retrieve outside temp from free API service like OpenWeatherMap +outdoor unit, communicates temperature to "master" ESP32 on heater unit over ESP-NOW+
- (LOW PRIO, MAYBE LATER) master forwards to MQTT for monitoring/graphing

** Challenges
- ✓ eBUS communication protocol (pretty much got this down)
- Valliant's eBUS commands are proprietary
- ESP32 ULP programming is in assembler

* tasks
Tasks should re-ordered so the first items should be the first things to pick up, items that are DONE need to move to [[* project log]]

** TODO determine preferred topology to use  (work in progress)
+consider ESP-NOW so "sensor" modules can profit from reduced "ON" time.+

+This needs a "master" though to forward to MQTT if required.+

+Good read and entry point is here: https://hackaday.io/project/174898-esp-now-weather-station+

New idea on topology is to use a single ESP32 as thermostat which harvests energy from eBUS for power.

The advantage is that there is no wireless communication needed for basic thermostat functionality.

This does however require a more sophisticated power design as we need a LiPo battery (or similar) with circuitry and most likely use of ESP32 ULP to stay within the power budget.

Wireless connectivity is still possible for things like getting NTP, outside temperature from a free API service and communicating as a telegram bot, but display and wireless need to repect the available energy budget.
** TODO prototype switching display on and off with mosfet
When operating in power-harvest mode we do not want the display on when maintenance chores are done.

The display does not have a pin to regulate the backlight, so it needs to be switched off completely when in sleep mode.
** TODO integrate a rotary encoder and buttons (capacitive?) for controlling the controller
** TODO integrate room temperature sensor
** TODO [#B] prototype power harvesting
Starting point are project that use solar energy like here https://randomnerdtutorials.com/power-esp32-esp8266-solar-panels-battery-level-monitoring/

This will include staring to use ESP32 ULP programming in assembler to measure the voltage/battery level in low power mode
** TODO [#C] create PCB with all components integrated
All basic functionality needs to be prototyped and tested before doing this.

Consider using JLCPCB assembly, this way we can use SMD without the hassle of sourcing SMD components, let alone soldering them
** TODO [#C] create case for thermostat unit

* documentation
** calculating power usage

#+NAME: ebusd raw log for getting data
#+BEGIN_SRC sh
2021-10-26 07:24:00.949 [update notice] sent read bai PartloadHcKW QQ=31: 20
2021-10-26 07:24:00.951 [bus notice] >3108b509030d0704ee<0001148f>00
2021-10-26 07:27:48.647 [update notice] sent read bai ModulationTempDesired QQ=31: 35.0
2021-10-26 07:27:48.650 [bus notice] >3108b509030d2e000c<00025e01a2>00
#+END_SRC

#+NAME: calculate current power for heating
#+BEGIN_SRC C
CurrentPower = PartloadHcKW * ModulationTempDesired / 100%

CurrentPower = 20 * 35.0 /100 = 7KW
#+END_SRC

discussion on calculating power consumption: https://github.com/john30/ebusd-configuration/issues/89

** code coverage
After running tests, code coverage report can be generated by executing the following commands:

#+NAME: code coverage generation
#+BEGIN_SRC sh
$ lcov --capture --directory .pio/build --output-file coverage.info
$ genhtml coverage.info --output-directory out
#+END_SRC

** display

[[./docs/img/2-Inch-TFT-Color-Screen-LCD-Display-Module.png]]

driver IC: ST7789VW

size: 240x320 px

library used: TFT\under{}eSPI

bought here: https://www.aliexpress.com/item/4000830895622.html

| pinout | meaning          | ESP32   | note       |
|--------+------------------+---------+------------|
| CS     | chip select      | GND     | active low |
| DC     | SPI Data Command | GPIO 27 |            |
| RST    | Reset            | GPIO 5  |            |
| SDA    | SPI MOSI         | GPIO 23 |            |
| SCL    | SPI clock        | GPIO 18 |            |
| VCC    |                  | +3.3    |            |
| GND    |                  | GND     |            |

** random assortment of links
 - http://www.pittnerovi.com/jiri/hobby/electronics/ebus/index.html
 - https://github.com/slavikb/BaiMon/blob/master/BaiMon.ino
 - https://www.14core.com/wiring-and-flashing-programming-esp-32-esp32s-with-usb-ttl-uart/
 - https://www.thingforward.io/techblog/2017-08-08-embedded-testing-with-platformio-part-2.html
 - set datetime: https://github.com/john30/ebusd/issues/286
 - formatting C time struct: https://www.ibm.com/docs/en/i/7.3?topic=functions-strftime-convert-datetime-string

* project log
** DONE create hardware interface for eBUS
    CLOSED: [2021-01-17 Sun 01:48]
** DONE get hardware interface to work with ebusd and experiment a bit
    CLOSED: [2021-01-17 Sun 01:48]
** DONE build bus power supply so testing can be done in stand-alone mode
    CLOSED: [2021-01-17 Sun 01:50]
** DONE experiment with programming new ESP32 boards
    CLOSED: [2021-01-18 Mon 03:19]
that was easy as pie :)
** DONE get ESP32 to listen in on eBUS messages and forward them ad-verbum to serial port for monitoring/debugging
    CLOSED: [2021-01-24 Sun 05:14]
** DONE implement queues for actions "to be done" and "messages completed"
   CLOSED: [2021-08-30 Mon 00:29]
status:

implemented a pretty simple queue

later i found out about the provided facilities of FreeRTOS (live and learn...)

the simple mock queue is however still very usefull for unit-testing in native mode

actual implementation will use FreeRTOS queues provided by ESP-IDF/FreeRTOS
** DONE learn how to use FreeRTOS queues
     CLOSED: [2021-01-24 Sun 05:13]
** DONE use queues for storing historic message
     CLOSED: [2021-01-24 Sun 05:15]

** DONE reply to "Identification (Service 07h 04h)"
    CLOSED: [2021-01-24 Sun 04:28]

** DONE tackle the arbitration challenge
   CLOSED: [2021-08-30 Mon 00:29]
** DONE get ESP board to interface with 2.0" display
   CLOSED: [2021-08-29 Sun 19:06]
** DONE setup polls for basic data and extract the relevant data from the responses
   CLOSED: [2021-09-04 Sat 00:55]
suggested for this todo are some of the messages already known:
- FlowTemp
- ReturnTemp
- HwcWaterflow
- Flame

As a reward these values can already be put on display, gaining some instant gratification and bragging rights.

** DONE connect to WiFi
   CLOSED: [2021-09-05 Sun 19:55]
** DONE Setup and display time over NTP
   CLOSED: [2021-09-05 Sun 22:01]
** DONE display eBUS connectivity
   CLOSED: [2021-09-06 Mon 01:29]
** DONE figure out what our power budget is
   CLOSED: [2021-09-06 Mon 17:58]
   Shorting 390 Ohm across the eBUS still held an upper voltage of 20.2V and bus seemed to work fine.

   This equals a current draw of ~52mA, or 1.06W, this is actually quite substantial, this was measured with a really tiny copper wire (telephone wire) connection to the heater, so losses will be less on thicker wiring.

   Using 220 Ohm the bus still managed to do some communication but errors did occur, the maximum voltage dropped to 19.2V. This equals a current draw of ~87mA and a power of 1.68W! The resistor got really toasty and discoloured!

   At 336 Ohm (60mA, 1.2W) bus still behaved perfectly.

   In conclusion, round about 50mA or a little more seems to be a very safe limit with only a single device on the bus besides the heater.
** +Broadcast datetime+
+Send broadcast of datetime and check ebusd messages 'DCFState', 'DCFTimeDate', 'DateTime'.+

My line of thinking was completely wrong, i assumed the DCF77 device was "Yet Another eBUS device". It is not. It is a module connected to a separate port on the heater. The broadcasts (presumably) are by the heater when it has detected a DCF signal.

Further more, i have not found any way to set the date/time on the heater through eBUS, and believe me, i've tried.

In the end it is not really relevant anyway, the room controller takes on the full role of director anyway when controlling the heater over eBUS, so the date/time on the heater is then completely irrelevant.
** +send current room temperature to heater+
Irrelevant for the same reason outlined in [[* +Broadcast datetime+]], in eBUS mode the heater is just a rather dumb slave dancing to the tune of puppet master room controller

** DONE setup separerate ESP32 as temperature logger
   CLOSED: [2021-09-14 Tue 08:00]
read sensor and output value to serial port
** DONE setup ESP-NOW and communicate temperature sensor readings to room controller
   CLOSED: [2021-09-14 Tue 19:16]
** DONE switch ESP-NOW polling from master to slave
   CLOSED: [2021-09-20 Mon 03:08]
It makes little sense for the master to loose WiFi connection to send beacons because of channel switching. Instead the slave(s) should do this as they have no active WiFi connection to begin with.
** DONE implement HMAC on ESP-NOW messages
   CLOSED: [2021-09-22 Wed 00:22]
Data sent over ESP-NOW is not sensitive so encryption is not very relevant. However, we do not want rogue data being operated on by the controller.

## KiCad design hardware/outdoor-sensor/outdoor-sensor.kicad_pcb

Parts:
C1: 100n; C_Disc_D6.0mm_W2.5mm_P5.00mm
J1: POWER; PinHeader_1x02_P2.54mm_Vertical
J2: UART; PinHeader_1x02_P2.54mm_Vertical
R1, R4: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 220k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 2.2M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: RESET; SW_SPST_B3S-1000
SW2: BOOT; SW_SPST_B3S-1000
U1: ESP32-WROOM-32
U2: DS18B20-PAR; TO-92_Inline

Connections:
+3V3: J1.1, R1.1, R2.1, R4.1, U1.2 (VDD)
/ADC1_CHAN_4: C1.1, R2.2, R3.1, U1.8 (IO32)
/BOOT: SW2.2, U1.25 (IO0)
/EN: R4.2, SW1.2, U1.3 (EN)
/RX: J2.1, U1.35 (TXD0/IO1)
/TEMP_DATA: R1.2, U1.26 (IO4), U2.2 (DQ)
/TX: J2.2, U1.34 (RXD0/IO3)
GND: C1.2, J1.2, R3.2, SW1.1, SW2.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.1 (GND)

Board: 2 copper layers, 11 parts (0 on the bottom side), 8 nets, no tracks yet.

## KiCad design ebus-adapter/ebus-adapter.kicad_pcb

Parts:
C1: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2: 10uF; CP_Radial_D5.0mm_P2.00mm
D1, D2, D3, D4, D5: 1N914; D_DO-35_SOD27_P7.62mm_Horizontal
D6: 1N4737A; D_DO-41_SOD81_P10.16mm_Horizontal
J1: EBus-Connector; TerminalBlock_bornier-2_P5.08mm
J2: Serial; PinHeader_1x04_P2.54mm_Vertical
LED1: SEND; LED_D3.0mm
LED2: RECV; LED_D3.0mm
Q1: BC337; TO-92_Inline
R1: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R5, R7: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 20k; Potentiometer_Bourns_3386F_Vertical
U1: L7805; TO-92L_Inline
U2: LM393N; DIP-8_W7.62mm
U3, U4: 4N25; DIP-6_W7.62mm

Connections:
+5V: C2.1, R3.1, R4.1, RV1.1, U1.1, U2.8 (V+)
GNDA: C1.2, C2.2, D3.2 (A), D4.2 (A), Q1.3 (E), R2.2, R7.2, RV1.3, U1.2, U2.4 (V-)
unnamed: C1.1, D1.1 (K), D2.1 (K), D5.2 (A), U1.3
unnamed: D1.2 (A), D3.1 (K), J1.1 (Ebus+)
unnamed: D2.2 (A), D4.1 (K), J1.2 (EBus-)
unnamed: D5.1 (K), D6.1 (K), R1.1
unnamed: D6.2 (A), Q1.1 (C)
unnamed: J2.1 (VCC), R5.1, R6.1
unnamed: J2.2 (RX), R5.2, U3.5
unnamed: J2.3 (TX), U4.2
unnamed: J2.4 (GND), U3.4
unnamed: LED1.1 (K), U4.5
unnamed: LED1.2 (A), R3.2
unnamed: LED2.1 (K), U3.1
unnamed: LED2.2 (A), R4.2
unnamed: Q1.2 (B), R7.1, U4.4
unnamed: R1.2, R2.1, U2.3 (+)
unnamed: R6.2, U4.1
unnamed: RV1.2, U2.2 (-), U2.5 (+)
unnamed: U2.1, U3.2
unnamed: U2.6 (_), U2.7

Board: 2 copper layers, 45.7 x 40.6 mm, 29 parts (0 on the bottom side), 21 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad

## Commit log (part)

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2021-01-03 initial schematic and board version
2021-01-03 initial platformio setup
2021-01-03 Corrected footprint of 7805 voltage ragulator
2021-01-04 Do not put *.net files in GIT
2021-01-04 do not store autosave files in GIT
2021-01-09 rename folder
2021-01-20 DEV COMMIT: map all data of incoming messages
2021-01-20 added org-mode project document
2021-01-20 Added folder with collected documentation
2021-01-20 Ignore generated HTML from org-mode
2021-01-20 dev commit: experimenting with temperature logger to MQTT
2021-01-21 Added queue for 'historic' telegrams
2021-01-21 clean-up
2021-01-21 only use own queue implementation for testing
2021-01-21 renamed queue.h to mock-queue.h
2021-01-21 switchover framwework from Arduino to ESP-IDF
2021-01-22 log historic messges from queue
2021-01-22 ignore menuconfig backups
2021-01-22 fixes after testing on device
2021-01-22 modify ports after reprogramming CP2102 on device
2021-01-22 some refactoring to make what to do on full queue configurable
2021-01-22 rename 'EbusState' to 'State'
2021-01-23 refactor to classes
2021-01-23 fix test for mock queue
2021-01-24 - refactor make things a lot more object-oriented - respond to identification command (0x07 0x04)
2021-01-24 minor refactoring
2021-01-24 update project log
2021-01-25 add send queue (not used yet)
2021-01-25 Split 'Telegram' class into 'Command' and 'Telegram' classes
2021-01-25 Split each class to separate header files
2021-01-25 rename 'ebus.* to 'Ebus.*'
2021-01-25 Rename 'activeTelegran' to 'receivingTelegram'
2021-01-28 Sending commands works
2021-01-28 Fix sending CRC
2021-01-28 use just a single enum for all telegram states
2021-01-28 Cleanup states
2021-01-28 Abort on UART errors
2021-01-29 Send ACK/NACK on responses we have requested
2021-01-29 change project name
2021-01-29 consistent define names
2021-01-29 formatting
2021-01-30 add listener
2021-01-30 fix test
2021-02-02 add additional PDF
2021-02-02 move links to project doc, add list of vaillant messages
2021-08-29 Display working with 'arduino, espdif' as framework
2021-08-29 Added some documentation
2021-08-29 minor comment
2021-08-30 remove listener
2021-09-01 Fix bug where the final sending of SYN after a command was escaped
2021-09-01 Use 'receivedByte' instead of 'cr' where possible
2021-09-01 Fixed bug where 'SendCommand's would always be retried at max attemtps
2021-09-01 small build_flags correction
2021-09-02 experimenting with fire animation
2021-09-02 minor visual improvements
2021-09-02 Got code coverage working
2021-09-03 Added heater address
2021-09-03 Added handler to interpret completed messages retrieved from the historic queue
2021-09-03 added handlers for reading device config messages
2021-09-05 added animated WiFi strength indicator sprite
2021-09-05 Enable WiFi provisioning through WifiManager
2021-09-05 project.org file update
2021-09-05 align task names with their function names
2021-09-05 Added system-info.h
2021-09-05 Show RSSI in animated network strenght icon
2021-09-05 include new 'system-info.h'
2021-09-05 Added 'no signal' to wifi strength indicator
2021-09-05 Forgot to erase no-signal cross when connection is (re)established
2021-09-05 Network configuration through WiFiManager is (finally) working correctly
2021-09-05 Get time from NTP
2021-09-05 Documentation update
2021-09-05 Store IP address in system_info and display it, also cleaned up some log messages along the way
2021-09-05 Seperate sub-struct for ebus related info in 'system_info'
2021-09-05 Added animated indicator for eBUS send queue
2021-09-06 Some UI rework: - drop text from eBUS queue widget - set queue and wifi widget to the same size - fix queue widget where old bars were not removed
2021-09-06 measured flow and confirmed it is indeed liters per minute
2021-09-06 added additional queue in between ISR and Ebus to prevent issues where ISR accesses code that is not in IRAM/DRAM
2021-09-06 Change order of startup sequence and add some short delays, this seems to fix the reboot issues
2021-09-06 Code cleanup
2021-09-06 Fixed enum that had 2 equal values
2021-09-10 Added handlers for responses we need to send
2021-09-10 fix unit test
2021-09-10 make 'handleResponse' private
2021-09-10 Use generated password and AP name
2021-09-10 Use chip id to set seed for generated password, this way the password stays the seem for each chip Upper 32 bits are used for password seed, lower 32 bit are show in AP name. Caveat Emptor: SEFM (sec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
2021-09-11 Update project doc
2021-09-11 commenting
2021-09-11 fix bug in logger where response CRC was shown for request
2021-09-11 spell eBUS consistently in project doc
2021-09-11 change project title
2021-09-11 rename 'logs' to 'project log' and move it to the bottom
2021-09-11 remove obsolete define
2021-09-11 ignore another .vscode file, not sure yet if i can ignore the entire dir
2021-09-14 Added minimal temperature logger
2021-09-14 remove old 'temp_logger'
2021-09-14 Rename 'setupWiFiAndKeepAlive' to 'wiFiLoop'
2021-09-14 cleanup gitignore
2021-09-14 Send temperature over ESP-NOW, hardcoded MAC for now
2021-09-15 Removed the hardcoded master MAC address, channel is still hardcoded
2021-09-15 Master can now detect slave without configured MAC address or channel
2021-09-15 Store state in RTC memory, this way master is already known after wake from deep sleep
2021-09-15 Refactored eBUS related code into separate file
2021-09-15 Disable defaul WiFi reconnect as it interfered with our own keep-alive code
2021-09-15 Renamed all file to have a consistent prefix
2021-09-15 Use everywhere consistently instead of
2021-09-15 Re-order includes
2021-09-15 move to
2021-09-15 Fix tests
2021-09-15 minor comment update
2021-09-15 refactor zebus-wifi
2021-09-15 Fix bug in logging
2021-09-16 When setting channel fails, disconnect and try again
2021-09-16 Fix log format
2021-09-16 cleanup: TFT object does not need to be shared
2021-09-16 cleanup
2021-09-16 more consistent includes
2021-09-16 Replace (almost) all with
2021-09-17 Moved some TFT config to
2021-09-17 Correct function name
2021-09-17 Set hostname in config
2021-09-17 Use X-macros to retrieve name of TelegramState
2021-09-17 Log failed eBUS telegrams
2021-09-18 Basic Telegram setup
2021-09-18 reverted settings for TFT display back to platformio.ini since they did not work as normal defines
2021-09-18 Moved TFT reset to GPIO5
2021-09-19 revert to initial color list as TFT_DARKGREY was duplicated
2021-09-20 Switch the burden of channel detection from master to slave
2021-09-20 Move setting for Telegram MBTS (Mean Time Between Service) to 'zebus-config.h'
2021-09-20 HMAC implemented, some code could do with a little more abstraction since there is some duplication
2021-09-21 remove some duplication
2021-09-22 Move device identification to config
2021-09-22 Add some more info to Telegram status reply
2021-09-22 Use logging instead of printf
2021-09-23 Use '_H' postfix for header file defines
2021-09-23 fix typo
2021-09-23 Set CPU frequency to 80MHz
2021-09-23 Set sensor interval from master
2021-09-23 Move call to 'nvs_flash_init()' to Wifi setup
2021-09-23 Rename 'wiFiLoop' to wiFiTask'
2021-09-23 Move eBus initialization to ebusTask
2021-09-23 Remove check on unit test as 'pio run' will not succeeed without a specified environmemt anywmore/anyway
2021-09-23 restructure 'zebus-display.cpp' to use up-front declarations
2021-09-23 correct typo
2021-09-24 Being to use FreeRTOS event groups to control system tasks
2021-09-24 Reduce number of debug messages
2021-09-24 simplify reading bits from events
2021-09-24 Do not block tasks indefinitely when no items are on the queue
2021-09-24 remove stale comments
2021-09-24 task 'processHistoricMessages' was hitting stack limit
2021-09-24 Encapsulate waiting for config portal to finish in 'runConfigPortal'
2021-09-24 Bring 'setupWiFi' into the main loop of 'wiFiTask'
2021-09-24 Minor refactoring on display
2021-09-24 Pass event group to 'wiFiTask', NOT USED YET
2021-09-24 Add states and demo for WiFi, NOT WORKING YET
2021-09-25 Use event group to enable WiFi
2021-09-25 Switching WiFi on and off now works
2021-09-25 Start esp-now after wifi has been restarted
2021-09-26 Correctly store and display flow
2021-09-26 Prevent overflow reading request and response buffers
2021-09-26 Use upfront declaration in zebus-messages.cpp
2021-09-26 fix another off-by-one error since the last byte in the buffer should be the CRC and is not part of the data
2021-09-26 prevent 'getNN()' and 'getResponseNN()' from returning values that are out of bounds
2021-09-26 Always pass an eBUS telegram as reference, not a copy
2021-09-27 Setup eBUS UART after it is fully initialized as it effectively starts eBUS. And do so in a critical section
2021-09-28 Cast result of EBUS_SLAVE_ADDRESS to uint8_t
2021-09-28 Add helper functions for creating SendCommands
2021-09-28 Rename task function from 'processHistoricMessages' to 'processReceivedMessages'
2021-09-28 Rename 'historic' to 'received'
2021-09-30 disable CPU Freq switching as it hangs one of my ESP32's
2021-09-30 Ad workaround (kludge) for detecting DS18B20 in parasitic mode
2021-10-01 Add schematic for outdoor sensor
2021-10-01 Add 3D tools
2021-10-01 Add original flexbatter tools
2021-10-01 remove warnings
2021-10-02 Read FlowTemp and ReturnTemp, only logged to console for now
2021-10-02 add 'deepen' option for CR132 battery
2021-10-02 add first version of outdoor sensor housing
2021-10-02 Create LICENSE
2021-10-03 Swap out DS18B20 for DS18B20-PAR
2021-10-04 switch to espidf
2021-10-04 Switch to using sdkconfig.defaults
2021-10-04 remove references to featheresp32 which were always a lie anyway and just name the env 'dev'
2021-10-07 Disable interrupts while reading temperatures
2021-10-07 add comment
2021-10-07 remove commented section regarding setting CPU freq as this is now done in sdkconfig
2021-10-16 Set DS18B20 resolution to 9 bits (0.5 °C) to reduce uptime
2021-10-16 Make sure WiFi config is read from flash when reconnecting
2021-10-16 Add command to read whether EBus control is recognized
2021-10-18 added link to discussion over calculating power usage
2021-10-18 Disable code to periodically shutdown WiFi
2021-10-18 added comment on disabled code
2021-10-26 Retrieve the values needed for calculating current power usage
2021-10-26 Set hostname to 'zebus'
2021-10-27 First setup of PID control for temperature
2021-10-27 reserve more stack space for temparatureControlTask
2021-11-01 Setup logging to MQTT
2021-11-03 rename struct
2021-11-03 Set location in sensor
2021-11-03 allow for multiple sensors
2021-11-03 Add define EBUS_INVALID_RESPONSE_BYTE
2021-11-04 Verify response length before reading data
2021-11-04 introduce 'ebus_tick' and set interval differently for messages according to time "criticallity" (in quotes since non of this is really time critical
2021-11-05 3D model tweaking
2021-11-06 add helper functions for intervals
2021-11-07 make logging a lot less verbose by only reporting changes on certain values
2021-11-07 rename zebus-events.* to zebus-state.*
2021-11-08 further rename 'event' to 'state'
2021-11-11 set timestamp on measurements even when value has not changed
2021-11-11 Make things more event driven
2021-11-11 fix wrong registration for queue-size handler
2021-11-11 Update sensors only once per minute
2021-11-14 remove obsolete function declaration
2021-11-19 switch to using state-machine for display, display now keeps working while fading
2021-11-23 minor improvement
2021-11-26 prevent replay by adding a nonce to ESP-NOW messages
2021-11-26 Cleanup header #ifndef's
2021-11-27 Add copy-assignment operator to measurement types
2021-11-27 fix PID input
2021-11-28 simplified datatypes, with a little more debug logging as a consequence
2021-11-28 Simplified reading EBus responses
2021-11-28 Added sub-folder for network related code
2021-11-28 Split MQTT and ESPNOW related code into separate files
2021-11-28 Added sub-folder for display related code and put code for sprites in separate files
2021-11-28 refactor palette code
2021-11-28 fix redeclaration warning
2021-11-28 De-arduino zebus-espnow.cpp
2021-11-28 tighten includes
2021-11-28 De-arduino zebus-mqtt.cpp
